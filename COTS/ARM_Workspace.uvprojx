# Keil uVision project ARM_Workspace.uvprojx, settings and files
target LED Blink (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM_Workspace
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\APP;.\HAL\LED\Inc;.\HAL\LED\Src;.\LIBRARIES\Common;.\LIBRARIES\CpuDriver\inc;.\LIBRARIES\CpuDriver\src;.\MCAL\DIO\inc;.\MCAL\DIO\Src;.\MCAL\INTERRUPT\Inc;.\MCAL\INTERRUPT\Src;.\MCAL\PORT\Inc;.\MCAL\PORT\Src;.\MCAL\SYSTICK\Inc;.\MCAL\SYSTICK\Src;.\MCAL\TIMER\Inc;.\MCAL\TIMER\Src;.\MCAL\DIO\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./MCAL/DIO/Src/: Dio.c
    ./MCAL/INTERRUPT/Inc/: IntCtrl.h IntCtrl_Cfg.h IntCtrl_Types.h
    ./MCAL/INTERRUPT/Src/: IntCtrl.c IntCtrl_Lcfg.c
    ./MCAL/PORT/Src/: Port.c Port_Lcfg.c
    ./MCAL/SYSTICK/Src/: Systick.c
    ./MCAL/SYSTICK/Inc/: Systick.h
    ./MCAL/TIMER/Inc/: Timer.h Timer_Cfg.h Timer_CfgTypes.h
    ./MCAL/TIMER/Src/: Timer.c
    ./MCAL/DIO/inc/: Dio.h Dio_Types.h
    ./MCAL/PORT/Inc/: Port_Cfg.h
  group HAL
    ./HAL/LED/Inc/: Led.h Led_Lcfg.h ISRs.h
    ./HAL/LED/Src/: Led.c ISRs.c
  group APP
    ./APP/: main.c
  group LIB
    ./LIBRARIES/Common/: Bit_Math.h Compiler.h Mcu_Hw.h Platform_Types.h Std_Types.h
    ./LIBRARIES/CpuDriver/src/: cpu_driver.c
    ./LIBRARIES/CpuDriver/inc/: cpu_driver.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
